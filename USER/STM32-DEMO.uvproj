# Keil uVision project STM32-DEMO.uvproj, settings and files
target LED-DEMO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\APP;..\BSP;..\uCOS-II\Ports;..\uCOS-II\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_iwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../BSP/: BSP.c led.c usart1.c usart2.c usart3.c flash.c esp8266.c RS485.c crc16.c Iwdg.c DS18B20.c
  group APP
    ../APP/: app.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
